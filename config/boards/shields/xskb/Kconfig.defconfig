## config/boards/shields/xskb/Kconfig.defconfig
```kconfig
if SHIELD_XSKB

config ZMK_KEYBOARD_NAME
    default "XSKB"

CONFIG_EC11=y
CONFIG_EC11_TRIGGER_GLOBAL_THREAD=y

endif
```
